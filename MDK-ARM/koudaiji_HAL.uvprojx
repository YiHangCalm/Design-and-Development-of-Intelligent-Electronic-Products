# Keil uVision project koudaiji_HAL.uvprojx, settings and files
target koudaiji_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: koudaiji_HAL +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\HardWare\inc;..\StateMachine\inc;..\Dsp\Include;..\SourceFile
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c core.c usart.c tim.c adc.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group HardWare
    ../HardWare/src/: led.c beep.c lcd.c touch_key.c sys_font.c vision.c voice.c diwen_lcd.c infared.c tripod.c matrix_key.c power.c relay.c
  group StateMachine
    ../StateMachine/src/: run_fast.c run_manual.c run_mode.c run_slow.c run_static.c run_stop.c logic.c osci.c
  group Dsp
    ../Dsp/: arm_cortexM4lf_math.lib
  group SourceFile
    ../SourceFile/: LcdDriver.cpp LcdDriver.h UI.cpp UI.h
software components: CMSIS:CORE 4.3.0
